Transformer

.SUBCKT LM7805CT 3 1 2
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
**************************************
*node 1: VREG (OUTPUT)
*node 2: Ground (Common)
*node 3: Line Voltage
ECCX 131 2 135 2 1.0
VXX 133 2 DC 0
FSET6 2 135 VSENS2 1
FPP 3 2 VXX 1.0
R_YY 31 2 1e6
R_XX 15 2 1e8
R_ZZ 36 2 1e6
R_QQ 65 2 1e8
RXX 1 2 1e8
VSENS1 10 1 DC 0
ISET 2 15 DC 1e-3
DON1 15 16 DMOD1
VSENS2 16 19 DC 0
DON2 15 17 DMOD1
EON2 18 2 3 2 1
FYY 3 2 VSENS1 1
DON3 15 27 DMOD1
VDROP3 28 27 DC 2
EON3 28 2 3 2 4
ELINE 13 42 66 2 1
FSET2 2 36 VSENS2 1
DSC1 36 35 DMOD1
RCL1 36 37 10
DSC2 37 38 DMOD1
ESCCON 38 39 30 2 1
VSCCON 39 40 DC 0
FSC 19 2 VSCCON 1
FSET3 2 31 VSENS2 1
DOV1 31 32 DMOD1
EOV1 32 2 3 1 1
DOV2 31 33 DMOD1
ISET4 2 30 DC 1e-3
ELOAD 41 2 77 2 -1
ERIPPLE 42 41 72 2 1
EREF 12 13 19 2 1
E3 52 2 3 2 1
CBYPS 54 2 0.001
VORB 54 60 DC 0
RB 60 2 1e3
RBR 72 2 1000
CBS2 52 71 1
RSTEP 77 2 1
FRB 2 65 VORB 1
DRB2 65 67 DMOD1
VXRB 67 68 DC -1
EXRB 68 2 1 2 1
DRB1 65 66 DMOD1
RB1 66 2 1000
.MODEL DMOD1 D
*-- DMOD1 DEFAULT PARAMETERS
*IS=1e-14 RS=0 N=1 TT=0 CJO=0
*VJ=1 M=0.5 EG=1.11 XTI=3 FC=0.5
*KF=0 AF=1 BV=inf IBV=1e-3 TNOM=27
EXX 132 131 3 131 0.0444444
RST6 135 2 10000
RIQX 133 132 RQIX 2222.22
.MODEL RQIX R TC1=-0
RSET 19 2 RSET 5000
.MODEL RSET R TC1=1e-05 TC2=-1.5005e-06
RS1 10 12 0.0075
VDROPX 18 17 1.46
HSENSE1 35 2 VSENS1 4.16667
RISC 30 2 RISC 10000
.MODEL RISC R TC1=-0.0025
ROV 34 2 20000
VOV 33 34 10
EOV2 2 40 34 2 0.291667
FIQD 3 2 VSENS1 0.0003
RY 52 54 5e+06
RA 72 73 2162.75
RYR 71 72 9.999e+06
CRA 52 73 1.59136e-11
HSTEP 76 2 VSENS1 1
CSTEP 76 77 6e-06
.ENDS
*============= Model template =================
*x%p %tIN %tOUT %tGND %m

.MODEL DB101 D(Is=7.32p BV=50 n=1.5 RS=0.05)

* input
V1 1 0 SIN(0 169.706 60)
RS 1 2 0.1

* transformer
L1 2 0 100m
L2 3 0 1m
k1 L1 L2 1
Rsim 0 0 100M

* full rectifier
D1 3 6 DB101
D2 4 5 DB101
D3 4 3 DB101
D4 5 6 DB101

* filter
CF 6 0 2.63m

* regulator
Xreg 6 7 0 LM7805CT

* load
CL 7 0 0.1u
RL 7 0 100

.tran 0.01 .1

.end
